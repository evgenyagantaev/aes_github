# IAR project stm32_vest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RG ST STM32F205RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX
  ICCARM.CCIncludePath2: Libraries\CMSIS\Device\ST\STM32F2xx\Include; Libraries\CMSIS\Include; Libraries\STM32F2xx_StdPeriph_Driver\inc; ; FreeRTOS\include; FreeRTOS\portable\IAR\ARM_CM3\; Classes; tasks; Libraries\SDIO_Driver\; Libraries\fatfs\src\; Libraries\flash\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: stm32_vest.bin
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    Libraries/Flash/: flash_if.c
    ./: FreeRTOSConfig.h main.h main_test.cpp stm32f2xx_conf.h stm32f2xx_it.c
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
    Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group FatFs
    Libraries/fatfs/src/: ff.c
    Libraries/fatfs/src/option/: unicode.c
  group FreeRTOS
    FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    FreeRTOS/portable/MemMang/: heap_3.c
    FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s
  group SDDriver
    Libraries/SDIO_Driver/: stm32_sdio_common.c stm32_sdio_sd.c
  group StdPeriphLib
    Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
